# Repository mjhaahr/RGB-LED-Pendant

File README.md:

# Small RGB LED Pendant with User-Selectable Patterns

Features:
- 177 Addressable RGB LEDs
    - WS2812B-style (NeoPixel) control
    - Xinglight XL-1010RGBC-WS2812B
- Two-board design for tight packaging
    - Front board contains the LED Matrix
    - Back board holds the Microcontroller, IMU, and Power Regulation
- ESP32-C3 Module for control
    - Allows pattern changing over WiFi/Bluetooth, as well as the buttons on the device
- Onboard IMU to generate reactive patterns
    - Utilizes a Bosch BNO055 for the simplicity of the orientation solution
- USB C Port for Power, Comms, and Programming
    - Connects to the ESP32-C3's onboard USB-CDC/JTAG device

## Table Of Contents
- [Bill Of Materials](#bill-of-materials)
- [Fabrication and Assembly](#fabrication-and-assembly)
- [Case Design](#case-design)
- [Code](#code)
- [Extra Notes](#extra-notes)

## Bill of Materials
- 1x Espressif ESP32-C3-MINI-1 - Microcontroller Module w/ WiFi and Bluetooth
    - [Datasheet](https://www.espressif.com/sites/default/files/documentation/esp32-c3-mini-1_datasheet_en.pdf)
    - [LCSC Part Number: C2934569](https://www.lcsc.com/product-detail/WiFi-Modules_Espressif-Systems-ESP32-C3-MINI-1-H4_C2934569.html)
    - Component: U1
- 1x Diodes Incorporated AP2112K-3.3 - Fixed 3V3 Regulator
    - [Datasheet](https://www.diodes.com/assets/Datasheets/AP2112.pdf)
    - [LCSC Part Number: C51118](https://www.lcsc.com/product-detail/Voltage-Regulators-Linear-Low-Drop-Out-LDO-Regulators_Diodes-Incorporated-AP2112K-3-3TRG1_C51118.html)
    - Component: U2
- 1x Bosch Sensortec BNO055 - Absolute Orientation Sensor - 9 Axis IMU and Sensor Fusion Processor
    - [Datasheet](https://www.bosch-sensortec.com/media/boschsensortec/downloads/datasheets/bst-bno055-ds000.pdf)
    - [LCSC Part Number: C93216](https://www.lcsc.com/product-detail/Accelerometers_Bosch-Sensortec-BNO055_C93216.html)
    - Component: U3
- 1x TI SN74LVC1T45DCK - Logic Level Translator
    - [Datasheet](https://www.ti.com/lit/ds/symlink/sn74lvc1t45.pdf)
    - [LCSC Part Number: C9382](https://www.lcsc.com/product-detail/Translators-Level-Shifters_Texas-Instruments-SN74LVC1T45DCKR_C9382.html)
    - Component: U4
- 1x Tech Public TPD2EUSB30 - 2-Channel USB ESD/TVS Diode (Clone of TI part with the same name)
    - [Datasheet](https://www.ti.com/lit/ds/symlink/tpd2eusb30.pdf)
    - [LCSC Part Number: C5182099](https://www.lcsc.com/product-detail/ESD-and-Surge-Protection-TVS-ESD_TECH-PUBLIC-TPD2EUSB30DRTR_C5182099.html)
    - Component: D1
- 1x TI ESD441 - 1-Channel VBUS ESD Diode
    - [Datasheet](https://www.ti.com/lit/ds/symlink/esd441.pdf)
    - [LCSC Part Number: C22427765](https://www.lcsc.com/product-detail/ESD-and-Surge-Protection-TVS-ESD_Texas-Instruments-ESD441DPLR_C22427765.html)
    - Component: D2
- 1x XINGLIGHT XL-1608SYGC-04 - Green LED
    - [Datasheet](https://www.lcsc.com/datasheet/lcsc_datasheet_2410121310_XINGLIGHT-XL-1608SYGC-04_C965806.pdf)
    - [LCSC Part Number: C965806](https://www.lcsc.com/product-detail/LED-Indication-Discrete_XINGLIGHT-XL-1608SYGC-04_C965806.html)
    - Component: D3
- 177x Xinglight XL-1010RGBC-WS2812B - 1mm x 1mm Addressable RGB LED
    - [Datasheet](https://www.lcsc.com/datasheet/lcsc_datasheet_2410121315_XINGLIGHT-XL-1010RGBC-WS2812B_C5349953.pdf)
    - [LCSC Part Number: C5349953](https://www.lcsc.com/product-detail/RGB-LEDs-Built-in-IC_XINGLIGHT-XL-1010RGBC-WS2812B_C5349953.html)
    - Component: D4-D180
- 3x Bossie BX-TS-26-342TP - SMD Tactile Push Buttons:
    - [Datasheet](https://www.lcsc.com/datasheet/lcsc_datasheet_2410121625_Bossie-BX-TS-26-342TP_C18078117.pdf)
    - [LCSC Part Number: C18078117](https://www.lcsc.com/product-detail/Tactile-Switches_Bossie-BX-TS-26-342TP_C18078117.html)
    - Component: SW1-SW3
- 1x G-Switch GT-USB-9010AB - USB 2.0 USB-C Connector (GCT-USB4105-GF Clone)
    - [Datasheet](https://www.lcsc.com/datasheet/lcsc_datasheet_2411221125_G-Switch-GT-USB-9010AB_C2988366.pdf)
    - [LCSC Part Number: C2988366](https://www.lcsc.com/product-detail/USB-Connectors_G-Switch-GT-USB-9010AB_C2988366.html)
    - Component: J1
- Headers (Used as Interboard Connectors)
    - 2x 2x2 Pin Socket - 1.27mm Pitch - Vertical SMD
        - Component: J2, J3
        - [LCSC Part Number: C5160799](https://www.lcsc.com/product-detail/Female-Headers_DEALON-DW127S-22-04-43_C5160799.html)
    - 1x 2x4 Pin Socket - 1.27mm Pitch - Vertical SMD
        - Component: J4
        - [LCSC Part Number: C5160801](https://www.lcsc.com/product-detail/Female-Headers_DEALON-DW127S-22-08-43_C5160801.html)
    - 2x 2x2 Pin Header - 1.27mm Pitch - Vertical SMD
        - Component: J5, J6
        - [LCSC Part Number: C5160758](https://www.lcsc.com/product-detail/Pin-Headers_DEALON-DZ127S-22-04-55_C5160758.html)
    - 1x 2x4 Pin Header - 1.27mm Pitch - Vertical SMD
        - Component: J7
        - [LCSC Part Number: C5160760](https://www.lcsc.com/product-detail/Pin-Headers_DEALON-DZ127S-22-08-55_C5160760.html)
- Capacitors
    - *All Packages are 0402 unless otherwise noted*
    - 10µF
        - Component: C1, C8, C9, C16
        - [LCSC Part Number: C7472949](https://www.lcsc.com/product-detail/Multilayer-Ceramic-Capacitors-MLCC-SMD-SMT_Chinocera-HGC0402R5106M100NTEJ_C7472949.html)
    - 100nF
        - Component: C2, C4, C5, C10, C13, C14, C17-C28
        - [LCSC Part Number: C1525](https://www.lcsc.com/product-detail/Multilayer-Ceramic-Capacitors-MLCC-SMD-SMT_Samsung-Electro-Mechanics-CL05B104KO5NNNC_C1525.html)
    - 1µF
        - Component: C3, C12, C15
        - [LCSC Part Number: C14445](https://www.lcsc.com/product-detail/Multilayer-Ceramic-Capacitors-MLCC-SMD-SMT_Samsung-Electro-Mechanics-CL05A105KP5NNNC_C14445.html)
    - 22pF
        - Component: C6, C7
        - [LCSC Part Number: C106203](https://www.lcsc.com/product-detail/Multilayer-Ceramic-Capacitors-MLCC-SMD-SMT_YAGEO-CC0402JRNPO9BN220_C106203.html)
    - 120nF
        - Component: C11
        - [LCSC Part Number: C7393864](https://www.lcsc.com/product-detail/Multilayer-Ceramic-Capacitors-MLCC-SMD-SMT_CCTC-TCC0402X7R124K160AT_C7393864.html)
- Resistors:
    - *All Packages are 0402 unless otherwise noted*
    - 3.3kΩ
        - Component: R1, R2
        - [LCSC Part Number: C25890](https://www.lcsc.com/product-detail/Chip-Resistor-Surface-Mount_UNI-ROYAL-Uniroyal-Elec-0402WGF3301TCE_C25890.html)
    - 10kΩ
        - Component: R3, R8, R9, R12
        - [LCSC Part Number: C25744](https://www.lcsc.com/product-detail/Chip-Resistor-Surface-Mount_UNI-ROYAL-Uniroyal-Elec-0402WGF1002TCE_C25744.html)
    - 1.3kΩ
        - Component: R4
        - [LCSC Part Number: C25866](https://www.lcsc.com/product-detail/Chip-Resistor-Surface-Mount_UNI-ROYAL-Uniroyal-Elec-0402WGF1301TCE_C25866.html)
    - 0Ω
        - Component: R5, R6
        - [LCSC Part Number: C17168](https://www.lcsc.com/product-detail/Chip-Resistor-Surface-Mount_UNI-ROYAL-Uniroyal-Elec-0402WGF0000TCE_C17168.html)
    - 100kΩ
        - Component: R7
        - [LCSC Part Number: C25741](https://www.lcsc.com/product-detail/Chip-Resistor-Surface-Mount_UNI-ROYAL-Uniroyal-Elec-0402WGF1003TCE_C25741.html)
    - 5.1kΩ
        - Component: R10, R11
        - [LCSC Part Number: C25905](https://www.lcsc.com/product-detail/Chip-Resistor-Surface-Mount_UNI-ROYAL-Uniroyal-Elec-0402WGF5101TCE_C25905.html)
    - 470Ω
        - Component: R13
        - [LCSC Part Number: C25117](https://www.lcsc.com/product-detail/Chip-Resistor-Surface-Mount_UNI-ROYAL-Uniroyal-Elec-0402WGF4700TCE_C25117.html)

## Fabrication and Assembly
- The boards were fabricated and assembled by JLCPCB
- The boards were combined into one frame to reduce the cost of having to make and assemble two designs in one order
- The frame was enlarged to fit the minimum board size for JLCPCB's PCBA service, as well as providing the necessary fiducials and edge rails for assembly

## Case Design
<!--- *TODO: Make Alternate with no Loop* --->

- 3D Printed Case with Keyring Loop
- Due to the small size, the two halves must be glued together, so ensure the whole pendant works before gluing together
- Included are the [CAD Files](case/Models) and [STLs](case/3D_Prints)

## Code
- Open the [Arduino Project](code/Small_Pendant) (Small_Pendant.ino and the rest of the directory)
- Ensure the ESP32 Arduino Core is installed and select the ESP32C3 Dev Module
- Plug in the pendant and click upload

## Extra Notes
- The [Only Pendant](https://github.com/mjhaahr/RGB-LED-Pendant/tree/Only_Pendant) branch features a much-simplified design, with only the LED Matrix and no control board; it functions the same as a normal NeoPixel matrix.
- A future version may replace the BNO055 with a more up-to-date IMU (and one that is a still active product) and move the orientation calculation onto the main MCU
- A future design may include an onboard battery and charger (would likely require enlarging the board or adding thickness to the design)
- During standup of V1 Hardware, it was found that an MCU strapping pin was forgotten (10kΩ pull-up on GPIO8)
    - To get the first run boards working, an 8.06kΩ 0603 pull-up resistor was added across pins 4 (GPIO8/`LED_Data`) and 6 (3V3) of U4
    - Fixed for future revision with a 10kΩ 0402 pull-up resistor placed closer to the MCU Module (U1)

## KiCad design Small_Pendant/Small_Pendant.kicad_pcb

Notes on the sheet:
All 177 RGB LEDs
Decoupling Caps Male Interboard Connectors
MCU USB Level Shift 3V3 Regulator Buttons Test Points Female Interboard Connectors

Parts:
C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28: 100nF; C_0402_1005Metric; LCSC Part C1525
J5, J6: Interboard-M1; HDR-SMD_4P-P1.27-V-M-R2-C2-S1.27-LS5.5; LCSC Part C5160758
J7: Interboard-M2; HDR-SMD_8P-P1.27-V-M-R2-C4-W5.5; LCSC Part C5160760
R13: 470; R_0402_1005Metric; LCSC Part C25117

Connections:
+5VL: C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, J5.1, J6.1, J6.2, J7.1, J7.2, J7.3, J7.4; also elsewhere on the board
DATA_IN: R13.2; also elsewhere on the board
GND: C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, J5.2, J6.3, J6.4, J7.5, J7.6, J7.7, J7.8; also elsewhere on the board
unnamed: J5.3, J5.4, R13.1

Parts:
C1, C8, C9, C16: 10uF; C_0402_1005Metric; LCSC Part C7472949
C2, C4, C5, C10, C13, C14: 100nF; C_0402_1005Metric; LCSC Part C1525
C3, C12, C15: 1uF; C_0402_1005Metric; LCSC Part C14445
C6, C7: 22pF; C_0402_1005Metric; LCSC Part C106203
C11: 120nF; C_0402_1005Metric; LCSC Part C7393864
D1: TPD2EUSB30; SOT-723_L1.2-W0.8-P0.80-LS1.2-BR; LCSC Part C5182099
D2: ESD441DPLR; X2SON-2_L0.6-W0.3-P0.35_ESD441DPLR; LCSC Part C22427765
D3: GREEN; LED_0603_1608Metric; LCSC Part C965806
J1: USB_C_Receptacle_USB2.0_16P; USB-C-SMD_G-SWITCH_GT-USB-9010AB; LCSC Part C2988366
J2, J3: Interboard-F1; HDR-SMD_4P-P1.27-V-F-R2-C2-LS4.8; LCSC Part C5160799
J4: Interboard-F2; HDR-SMD_8P-P1.27-V-F-R2-C4-LS4.8; LCSC Part C5160801
R1, R2: 3.3k; R_0402_1005Metric; LCSC Part C25890
R3, R8, R9: 10k; R_0402_1005Metric; LCSC Part C25744
R4: 1k3; R_0402_1005Metric; LCSC Part C25866
R5, R6: 0; R_0402_1005Metric; LCSC Part C17168
R7: 100k; R_0402_1005Metric; LCSC Part C25741
R10, R11: 5k1; R_0402_1005Metric; LCSC Part C25905
R12: 10k; R_0402_1005Metric
SW1, SW2, SW3: SW_Push; KEY-SMD_L3.9-W3.0-LS5.0-EH; LCSC Part C18078117
TP1: TX; TestPoint_Pad_0.5x0.5mm; not fitted
TP2: RX; TestPoint_Pad_0.5x0.5mm; not fitted
TP3: 3V3; TestPoint_Pad_0.5x0.5mm; not fitted
TP4: 5V; TestPoint_Pad_0.5x0.5mm; not fitted
TP5: GND; TestPoint_Pad_0.5x0.5mm; not fitted
U1: ESP32-C3-MINI-1; WIFIM-SMD_ESP32-C3-MINI-1; LCSC Part C2934569
U2: AP2112K-3.3; SOT-25-5_L2.9-W1.6-P0.95-LS2.8-BL; LCSC Part C22427765
U3: BNO055; LGA-28_L5.2-W3.8-P0.50-BL; LCSC Part C93216
U4: SN74LVC1T45DCK; SC-70-6_L2.2-W1.3-P0.65-LS2.2-BR; LCSC Part C9382

Connections:
+3V3: C1.1, C2.1, C9.1, C10.2, C11.1, C14.1, R1.2, R2.2, R3.1, R8.1, R9.1, R12.2, TP3.1, U1.3 (3V3), U2.5 (VOUT), U3.3 (VDD), U3.28 (VDDIO), U4.6 (VCCB)
+5V: C8.1, C13.1, C15.1, C16.1, D2.1 (K), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), J2.1, J3.1, J3.2, J4.1, J4.2, J4.3, J4.4, R7.1, TP4.1, U2.1 (VIN), U4.1 (VCCA)
/MCU/LED_BUILTIN: R4.2, U1.13 (GPIO1/ADC1_CH1/XTAL_32K_N)
/MCU/USB_D'+: C6.2, R5.1, U1.27 (GPIO19/USB_D+)
/MCU/USB_D'-: C7.2, R6.1, U1.26 (GPIO18/USB_D-)
CHIP_EN: C3.1, C4.1, R3.2, SW2.2, U1.8 (EN/CHIP_PU)
Earth: C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, C7.1, C8.2, C9.2, C10.1, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, D1.3 (GND), D2.2 (A), D3.1 (K), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J2.2, J3.3, J3.4, J4.5, J4.6, J4.7, J4.8, R10.2, R11.2, SW1.1, SW2.1, SW3.1, TP5.1, U1.1 (GND), U1.2 (GND), U1.11 (GND), U1.14 (GND), U1.36 (GND), U1.37 (GND), U1.38 (GND), U1.39 (GND), U1.40 (GND), U1.41 (GND), U1.42 (GND), U1.43 (GND), U1.44 (GND), U1.45 (GND), U1.46 (GND), U1.47 (GND), U1.48 (GND), U1.49 (GND), U1.50 (GND), U1.51 (GND), U1.52 (GND), U1.53 (GND), U2.2 (GND), U3.2 (GND), U3.5 (PS1), U3.6 (PS0), U3.17 (COM3), U3.18 (COM2), U3.25 (GNDIO), U4.2 (GND), U4.5 (DIR)
GPIO9/BOOT: C5.1, SW1.2, U1.23 (GPIO9)
IMU_INT: U1.16 (GPIO10), U3.14 (INT)
LED_DATA: R12.1, U1.22 (GPIO8), U4.4 (B)
LED_DATA_5V: J2.3, J2.4, U4.3 (A)
unnamed: D3.2 (A), R4.1
unnamed: J1.A5 (CC1), R11.1
unnamed: J1.B5 (CC2), R10.1
unnamed: TP2.1, U1.30 (GPIO20/U0RXD)
unnamed: TP1.1, U1.31 (GPIO21/U0TXD)
unnamed: R7.2, U2.3 (EN)
unnamed: C12.1, U3.9 (CAP)
unnamed: R9.2, U3.4 (NBOOT_LOAD_PIN)
unnamed: R8.2, U3.11 (NRESET)
SCL: R2.1, U1.6 (GPIO3/ADC1_CH3), U3.19 (COM1)
SDA: R1.1, U1.5 (GPIO2/ADC1_CH2), U3.20 (COM0)
USB_D+: D1.1 (IO1), J1.A6 (D+), J1.B6 (D+), R5.2
USB_D-: D1.2 (IO2), J1.A7 (D-), J1.B7 (D-), R6.2
USR_BTN: SW3.2, U1.12 (GPIO0/ADC1_CH0/XTAL_32K_P)

Notes on the sheet:
USB
Data Translation
Buttons
Patterns (And Wakeup)
PSU
Power Test Points
Strapping Pin
Interboard
MCU
Color Cycle
IMU

Parts:
D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68, D69, D70, D71, D72, D73, D74, D75, D76, D77, D78, D79, D80, D81, D82, D83, D84, D85, D86, D87, D88, D89, D90, D91, D92, D93, D94, D95, D96, D97, D98, D99, D100, D101, D102, D103, D104, D105, D106, D107, D108, D109, D110, D111, D112, D113, D114, D115, D116, D117, D118, D119, D120, D121, D122, D123, D124, D125, D126, D127, D128, D129, D130, D131, D132, D133, D134, D135, D136, D137, D138, D139, D140, D141, D142, D143, D144, D145, D146, D147, D148, D149, D150, D151, D152, D153, D154, D155, D156, D157, D158, D159, D160, D161, D162, D163, D164, D165, D166, D167, D168, D169, D170, D171, D172, D173, D174, D175, D176, D177, D178, D179, D180: XL-1010RGBC-WS2812B; XINGLIGHT-XL-1010RGBC; LCSC Part C5349953

Connections:
+5VL: D4.2 (VCC), D5.2 (VCC), D6.2 (VCC), D7.2 (VCC), D8.2 (VCC), D9.2 (VCC), D10.2 (VCC), D11.2 (VCC), D12.2 (VCC), D13.2 (VCC), D14.2 (VCC), D15.2 (VCC), D16.2 (VCC), D17.2 (VCC), D18.2 (VCC), D19.2 (VCC), D20.2 (VCC), D21.2 (VCC), D22.2 (VCC), D23.2 (VCC), D24.2 (VCC), D25.2 (VCC), D26.2 (VCC), D27.2 (VCC), D28.2 (VCC), D29.2 (VCC), D30.2 (VCC), D31.2 (VCC), D32.2 (VCC), D33.2 (VCC), D34.2 (VCC), D35.2 (VCC), D36.2 (VCC), D37.2 (VCC), D38.2 (VCC), D39.2 (VCC), D40.2 (VCC), D41.2 (VCC), D42.2 (VCC), D43.2 (VCC), D44.2 (VCC), D45.2 (VCC), D46.2 (VCC), D47.2 (VCC), D48.2 (VCC), D49.2 (VCC), D50.2 (VCC), D51.2 (VCC), D52.2 (VCC), D53.2 (VCC), D54.2 (VCC), D55.2 (VCC), D56.2 (VCC), D57.2 (VCC), D58.2 (VCC), D59.2 (VCC), D60.2 (VCC), D61.2 (VCC), D62.2 (VCC), D63.2 (VCC), D64.2 (VCC), D65.2 (VCC), D66.2 (VCC), D67.2 (VCC), D68.2 (VCC), D69.2 (VCC), D70.2 (VCC), D71.2 (VCC), D72.2 (VCC), D73.2 (VCC), D74.2 (VCC), D75.2 (VCC), D76.2 (VCC), D77.2 (VCC), D78.2 (VCC), D79.2 (VCC), D80.2 (VCC), D81.2 (VCC), D82.2 (VCC), D83.2 (VCC)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; also elsewhere on the board
DATA_IN: D4.4 (DI); also elsewhere on the board
DATA_THRU1: D23.1 (DO), D24.4 (DI)
DATA_THRU2: D43.1 (DO), D44.4 (DI)
DATA_THRU3: D63.1 (DO), D64.4 (DI)
DATA_THRU4: D83.1 (DO), D84.4 (DI)
DATA_THRU5: D103.1 (DO), D104.4 (DI)
DATA_THRU6: D123.1 (DO), D124.4 (DI)
DATA_THRU7: D139.1 (DO), D140.4 (DI)
DATA_THRU8: D155.1 (DO), D156.4 (DI)
DATA_THRU9: D171.1 (DO), D172.4 (DI)
GND: D4.3 (GND), D5.3 (GND), D6.3 (GND), D7.3 (GND), D8.3 (GND), D9.3 (GND), D10.3 (GND), D11.3 (GND), D12.3 (GND), D13.3 (GND), D14.3 (GND), D15.3 (GND), D16.3 (GND), D17.3 (GND), D18.3 (GND), D19.3 (GND), D20.3 (GND), D21.3 (GND), D22.3 (GND), D23.3 (GND), D24.3 (GND), D25.3 (GND), D26.3 (GND), D27.3 (GND), D28.3 (GND), D29.3 (GND), D30.3 (GND), D31.3 (GND), D32.3 (GND), D33.3 (GND), D34.3 (GND), D35.3 (GND), D36.3 (GND), D37.3 (GND), D38.3 (GND), D39.3 (GND), D40.3 (GND), D41.3 (GND), D42.3 (GND), D43.3 (GND), D44.3 (GND), D45.3 (GND), D46.3 (GND), D47.3 (GND), D48.3 (GND), D49.3 (GND), D50.3 (GND), D51.3 (GND), D52.3 (GND), D53.3 (GND), D54.3 (GND), D55.3 (GND), D56.3 (GND), D57.3 (GND), D58.3 (GND), D59.3 (GND), D60.3 (GND), D61.3 (GND), D62.3 (GND), D63.3 (GND), D64.3 (GND), D65.3 (GND), D66.3 (GND), D67.3 (GND), D68.3 (GND), D69.3 (GND), D70.3 (GND), D71.3 (GND), D72.3 (GND), D73.3 (GND), D74.3 (GND), D75.3 (GND), D76.3 (GND), D77.3 (GND), D78.3 (GND), D79.3 (GND), D80.3 (GND), D81.3 (GND), D82.3 (GND), D83.3 (GND)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; also elsewhere on the board
unnamed: D4.1 (DO), D5.4 (DI)
unnamed: D5.1 (DO), D6.4 (DI)
unnamed: D6.1 (DO), D7.4 (DI)
unnamed: D7.1 (DO), D8.4 (DI)
unnamed: D8.1 (DO), D9.4 (DI)
unnamed: D9.1 (DO), D10.4 (DI)
unnamed: D10.1 (DO), D11.4 (DI)
unnamed: D11.1 (DO), D12.4 (DI)
unnamed: D12.1 (DO), D13.4 (DI)
unnamed: D13.1 (DO), D14.4 (DI)
unnamed: D14.1 (DO), D15.4 (DI)
unnamed: D15.1 (DO), D16.4 (DI)
unnamed: D16.1 (DO), D17.4 (DI)
unnamed: D17.1 (DO), D18.4 (DI)
unnamed: D18.1 (DO), D19.4 (DI)
unnamed: D19.1 (DO), D20.4 (DI)
unnamed: D20.1 (DO), D21.4 (DI)
unnamed: D21.1 (DO), D22.4 (DI)
unnamed: D22.1 (DO), D23.4 (DI)
unnamed: D24.1 (DO), D25.4 (DI)
unnamed: D25.1 (DO), D26.4 (DI)
unnamed: D26.1 (DO), D27.4 (DI)
unnamed: D27.1 (DO), D28.4 (DI)
unnamed: D28.1 (DO), D29.4 (DI)
unnamed: D29.1 (DO), D30.4 (DI)
unnamed: D30.1 (DO), D31.4 (DI)
unnamed: D31.1 (DO), D32.4 (DI)
unnamed: D32.1 (DO), D33.4 (DI)
unnamed: D33.1 (DO), D34.4 (DI)
unnamed: D34.1 (DO), D35.4 (DI)
unnamed: D35.1 (DO), D36.4 (DI)
unnamed: D36.1 (DO), D37.4 (DI)
unnamed: D37.1 (DO), D38.4 (DI)
unnamed: D38.1 (DO), D39.4 (DI)
unnamed: D39.1 (DO), D40.4 (DI)
unnamed: D40.1 (DO), D41.4 (DI)
unnamed: D41.1 (DO), D42.4 (DI)
unnamed: D42.1 (DO), D43.4 (DI)
unnamed: D44.1 (DO), D45.4 (DI)
unnamed: D45.1 (DO), D46.4 (DI)
unnamed: D46.1 (DO), D47.4 (DI)
unnamed: D47.1 (DO), D48.4 (DI)
unnamed: D48.1 (DO), D49.4 (DI)
unnamed: D49.1 (DO), D50.4 (DI)
unnamed: D50.1 (DO), D51.4 (DI)
unnamed: D51.1 (DO), D52.4 (DI)
unnamed: D52.1 (DO), D53.4 (DI)
unnamed: D53.1 (DO), D54.4 (DI)
unnamed: D54.1 (DO), D55.4 (DI)
unnamed: D55.1 (DO), D56.4 (DI)
unnamed: D56.1 (DO), D57.4 (DI)
unnamed: D57.1 (DO), D58.4 (DI)
unnamed: D58.1 (DO), D59.4 (DI)
unnamed: D59.1 (DO), D60.4 (DI)
unnamed: D60.1 (DO), D61.4 (DI)
unnamed: D61.1 (DO), D62.4 (DI)
unnamed: D62.1 (DO), D63.4 (DI)
unnamed: D64.1 (DO), D65.4 (DI)
unnamed: D65.1 (DO), D66.4 (DI)
unnamed: D66.1 (DO), D67.4 (DI)
unnamed: D67.1 (DO), D68.4 (DI)
unnamed: D68.1 (DO), D69.4 (DI)
unnamed: D69.1 (DO), D70.4 (DI)
unnamed: D70.1 (DO), D71.4 (DI)
unnamed: D71.1 (DO), D72.4 (DI)
unnamed: D72.1 (DO), D73.4 (DI)
unnamed: D73.1 (DO), D74.4 (DI)
unnamed: D74.1 (DO), D75.4 (DI)
unnamed: D75.1 (DO), D76.4 (DI)
unnamed: D76.1 (DO), D77.4 (DI)
unnamed: D77.1 (DO), D78.4 (DI)
unnamed: D78.1 (DO), D79.4 (DI)
unnamed: D79.1 (DO), D80.4 (DI)
unnamed: D80.1 (DO), D81.4 (DI)
unnamed: D81.1 (DO), D82.4 (DI)
unnamed: D82.1 (DO), D83.4 (DI)
unnamed: D84.1 (DO), D85.4 (DI)
unnamed: D85.1 (DO), D86.4 (DI)
unnamed: D86.1 (DO), D87.4 (DI)
unnamed: D87.1 (DO), D88.4 (DI)
unnamed: D88.1 (DO), D89.4 (DI)
unnamed: D89.1 (DO), D90.4 (DI)
unnamed: D90.1 (DO), D91.4 (DI)
unnamed: D91.1 (DO), D92.4 (DI)
unnamed: D92.1 (DO), D93.4 (DI)
unnamed: D93.1 (DO), D94.4 (DI)
unnamed: D94.1 (DO), D95.4 (DI)
unnamed: D95.1 (DO), D96.4 (DI)
unnamed: D96.1 (DO), D97.4 (DI)
unnamed: D97.1 (DO), D98.4 (DI)
unnamed: D98.1 (DO), D99.4 (DI)
unnamed: D99.1 (DO), D100.4 (DI)
unnamed: D100.1 (DO), D101.4 (DI)
unnamed: D101.1 (DO), D102.4 (DI)
unnamed: D102.1 (DO), D103.4 (DI)
unnamed: D104.1 (DO), D105.4 (DI)
unnamed: D105.1 (DO), D106.4 (DI)
unnamed: D106.1 (DO), D107.4 (DI)
unnamed: D107.1 (DO), D108.4 (DI)
unnamed: D108.1 (DO), D109.4 (DI)
unnamed: D109.1 (DO), D110.4 (DI)
unnamed: D110.1 (DO), D111.4 (DI)
unnamed: D111.1 (DO), D112.4 (DI)
unnamed: D112.1 (DO), D113.4 (DI)
unnamed: D113.1 (DO), D114.4 (DI)
unnamed: D114.1 (DO), D115.4 (DI)
unnamed: D115.1 (DO), D116.4 (DI)
unnamed: D116.1 (DO), D117.4 (DI)
unnamed: D117.1 (DO), D118.4 (DI)
unnamed: D118.1 (DO), D119.4 (DI)
unnamed: D119.1 (DO), D120.4 (DI)
unnamed: D120.1 (DO), D121.4 (DI)
unnamed: D121.1 (DO), D122.4 (DI)
unnamed: D122.1 (DO), D123.4 (DI)
unnamed: D124.1 (DO), D125.4 (DI)
unnamed: D125.1 (DO), D126.4 (DI)
unnamed: D126.1 (DO), D127.4 (DI)
unnamed: D127.1 (DO), D128.4 (DI)
unnamed: D128.1 (DO), D129.4 (DI)
unnamed: D129.1 (DO), D130.4 (DI)
unnamed: D130.1 (DO), D131.4 (DI)
unnamed: D131.1 (DO), D132.4 (DI)
unnamed: D132.1 (DO), D133.4 (DI)
unnamed: D133.1 (DO), D134.4 (DI)
unnamed: D134.1 (DO), D135.4 (DI)
unnamed: D135.1 (DO), D136.4 (DI)
unnamed: D136.1 (DO), D137.4 (DI)
unnamed: D137.1 (DO), D138.4 (DI)
unnamed: D138.1 (DO), D139.4 (DI)
unnamed: D140.1 (DO), D141.4 (DI)
unnamed: D141.1 (DO), D142.4 (DI)
unnamed: D142.1 (DO), D143.4 (DI)
unnamed: D143.1 (DO), D144.4 (DI)
unnamed: D144.1 (DO), D145.4 (DI)
unnamed: D145.1 (DO), D146.4 (DI)
unnamed: D146.1 (DO), D147.4 (DI)
unnamed: D147.1 (DO), D148.4 (DI)
unnamed: D148.1 (DO), D149.4 (DI)
unnamed: D149.1 (DO), D150.4 (DI)
unnamed: D150.1 (DO), D151.4 (DI)
unnamed: D151.1 (DO), D152.4 (DI)
unnamed: D152.1 (DO), D153.4 (DI)
unnamed: D153.1 (DO), D154.4 (DI)
unnamed: D154.1 (DO), D155.4 (DI)
unnamed: D156.1 (DO), D157.4 (DI)
unnamed: D157.1 (DO), D158.4 (DI)
unnamed: D158.1 (DO), D159.4 (DI)
unnamed: D159.1 (DO), D160.4 (DI)
unnamed: D160.1 (DO), D161.4 (DI)
unnamed: D161.1 (DO), D162.4 (DI)
unnamed: D162.1 (DO), D163.4 (DI)
unnamed: D163.1 (DO), D164.4 (DI)
unnamed: D164.1 (DO), D165.4 (DI)
unnamed: D165.1 (DO), D166.4 (DI)
unnamed: D166.1 (DO), D167.4 (DI)
unnamed: D167.1 (DO), D168.4 (DI)
unnamed: D168.1 (DO), D169.4 (DI)
unnamed: D169.1 (DO), D170.4 (DI)
unnamed: D170.1 (DO), D171.4 (DI)
unnamed: D172.1 (DO), D173.4 (DI)
unnamed: D173.1 (DO), D174.4 (DI)
unnamed: D174.1 (DO), D175.4 (DI)
unnamed: D175.1 (DO), D176.4 (DI)
unnamed: D176.1 (DO), D177.4 (DI)
unnamed: D177.1 (DO), D178.4 (DI)
unnamed: D178.1 (DO), D179.4 (DI)
unnamed: D179.1 (DO), D180.4 (DI)

Notes on the sheet:
177 LEDs

Board: 4 copper layers, 75.0 x 70.0 mm, 248 parts (33 on the bottom side), 205 nets.

Other parts of the board:
mouse-bite-2mm-slot, mouse-bite-2mm-slot#2, mouse-bite-2mm-slot#3, mouse-bite-2mm-slot#4, mouse-bite-2mm-slot#5, mouse-bite-2mm-slot#6, mouse-bite-2mm-slot#7, mouse-bite-2mm-slot#8: VAL**; mouse-bite-2mm-slot_round

File Small_Pendant/Small_Pendant_Fab/Small_Pendant-bom.csv:

"Designator","Value","Qty","Footprint","LCSC Part"
"C1,C8,C9,C16","10uF","4","Capacitor_SMD:C_0402_1005Metric","C7472949"
"C2,C4,C5,C10,C13,C14,C17,C18,C19,C20,C21,C22,C23,C24,C25,C26,C27,C28","100nF","18","Capacitor_SMD:C_0402_1005Metric","C1525"
"C3,C12,C15","1uF","3","Capacitor_SMD:C_0402_1005Metric","C14445"
"C6,C7","22pF","2","Capacitor_SMD:C_0402_1005Metric","C106203"
"C11","120nF","1","Capacitor_SMD:C_0402_1005Metric","C7393864"
"D1","TPD2EUSB30","1","TPD2EUSB30DRTR:DRT0003A","C5182099"
"D2","ESD441DPLR","1","EasyEDA2KiCad:X2SON-2_L0.6-W0.3-P0.35_ESD441DPLR","C22427765"
"D3","GREEN","1","LED_SMD:LED_0603_1608Metric","C965806"
"D4,D5,D6,D7,D8,D9,D10,D11,D12,D13,D14,D15,D16,D17,D18,D19,D20,D21,D22,D23,D24,D25,D26,D27,D28,D29,D30,D31,D32,D33,D34,D35,D36,D37,D38,D39,D40,D41,D42,D43,D44,D45,D46,D47,D48,D49,D50,D51,D52,D53,D54,D55,D56,D57,D58,D59,D60,D61,D62,D63,D64,D65,D66,D67,D68,D69,D70,D71,D72,D73,D74,D75,D76,D77,D78,D79,D80,D81,D82,D83,D84,D85,D86,D87,D88,D89,D90,D91,D92,D93,D94,D95,D96,D97,D98,D99,D100,D101,D102,D103,D104,D105,D106,D107,D108,D109,D110,D111,D112,D113,D114,D115,D116,D117,D118,D119,D120,D121,D122,D123,D124,D125,D126,D127,D128,D129,D130,D131,D132,D133,D134,D135,D136,D137,D138,D139,D140,D141,D142,D143,D144,D145,D146,D147,D148,D149,D150,D151,D152,D153,D154,D155,D156,D157,D158,D159,D160,D161,D162,D163,D164,D165,D166,D167,D168,D169,D170,D171,D172,D173,D174,D175,D176,D177,D178,D179,D180","XL-1010RGBC-WS2812B","177","LED_SMD:XINGLIGHT-XL-1010RGBC","C5349953 "
"J1","USB_C_Receptacle_USB2.0_16P","1","Connector_USB:USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal","C2988366"
"J2,J3","Interboard-F1","2","Connector_PinSocket_1.27mm:PinSocket_2x02_P1.27mm_Vertical_SMD","C5160799"
"J4","Interboard-F2","1","Connector_PinSocket_1.27mm:PinSocket_2x04_P1.27mm_Vertical_SMD","C5160801"
"J5,J6","Interboard-M1","2","Connector_PinHeader_1.27mm:PinHeader_2x02_P1.27mm_Vertical_SMD","C5160758"
"J7","Interboard-M2","1","Connector_PinHeader_1.27mm:PinHeader_2x04_P1.27mm_Vertical_SMD","C5160760"
"R1,R2","3.3k","2","Resistor_SMD:R_0402_1005Metric","C25890"
"R3,R8,R9","10k","3","Resistor_SMD:R_0402_1005Metric","C25744"
"R4","1k3","1","Resistor_SMD:R_0402_1005Metric","C25866"
"R5,R6","0","2","Resistor_SMD:R_0402_1005Metric","C17168"
"R7","100k","1","Resistor_SMD:R_0402_1005Metric","C25741"
"R10,R11","5k1","2","Resistor_SMD:R_0402_1005Metric","C25905"
"R12","470","1","Resistor_SMD:R_0402_1005Metric","C25117"
"SW1,SW2,SW3","SW_Push","3","EasyEDA2KiCad:KEY-SMD_L3.9-W3.0-LS5.0-EH","C18078117"
"U1","ESP32-C3-MINI-1","1","MCU_Espressif_Official:ESP32-C3-MINI-1","C2934569"
"U2","AP2112K-3.3","1","Package_TO_SOT_SMD:SOT-23-5","C51118"
"U3","BNO055","1","BNO055:LGA28R50P4X10_380X520X100","C93216"
"U4","SN74LVC1T45DCK","1","Package_TO_SOT_SMD:SOT-363_SC-70-6","C9382"
