File: Small_Pendant/Small_Pendant.kicad_pcb (KiCad board)
At the start: 4 copper layers, 72.9 x 38 mm, 249 parts, among them J1 USB_C_Receptacle_USB2.0_16P, J2 Interboard-F1, J3 Interboard-F1, J4 Interboard-F2, J5 Interboard-M1, J6 Interboard-M1, J7 Interboard-M2, SW1 SW_Push, SW2 SW_Push, SW3 SW_Push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

Commit message: Fixed a few placement correlation issues
Still TODO:
J1: USB (Footprint generating DRC Errors)
J7: Interboard (Missing LCSC Part, wait for it to be added)
Parts:
- moved U1 2.49 mm to (85.0, 50.0)
- turned D1 to 180 degrees
- turned D2 to 0 degrees
- turned U2 to 180 degrees
Routing:
- net Earth: track 75.7 -> 73.8 mm
